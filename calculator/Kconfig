## calculator/src/lib/algos/src/Kconfig
```kconfig
source add/Kconfig
source sub/Kconfig

config ALGO
    select ADD
    select SUB
```
